Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Office-Chairs_Kinnarps_Claro-D-1053-DG-D-1053-DGLF-1053-VLF-DGL.ifc
Time: 2020-08-25T13:13:57
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Claro, D-1053-DG,D-1053-DGLF-1053-VLF-DGLF-NCL
ePset_BIMobjectScript - FITTINGS: Armrest; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Claro, D-1053-DG,D-1053-DGLF-1053-VLF-DGLF-NCL; SKU (BO_prodsku): D-1053_DG; ManufacturName (BO_Manufac): Kinnarps; BrandUrl (BO_brandurl): http://www.kinnarps.com/; ProductFamily (BO_prodfam): Task chairs; ProductGroup (BO_prodgroup): CLARO; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 6/23/2020; EditionNumber (BO_edinum): 1; Width (BO_width): 490; Height (BO_height): 0; Depth (BO_depth): 400; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/kinnarps/product/D-1053_DG; ProductDataUrl (BO_prodaturl): bimobject.com/kinnarps/product/D-1053_DG; ProductUrl (BO_producturl): https://www.kinnarps.com/products/seating/task-chairs/claro/; InstallationInstructions (BO_montins): https://www.kinnarps.com/globalassets/product-brochures/en/en_claro.pdf; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Plastic; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Office Chairs; BimObjectCategoryCode (BO_bocat_code): furniture-office-chairs; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L853; Uniclass14Description (BO_uniclass_1_4_desc): Office furniture; Uniclass20Code (BO_uniclass_2_0_code): PR-35-12-57; Uniclass20Description (BO_uniclass_2_0_desc): Office Chairs; NBSReference (BO_nbs_ref): 35-12-57; NBSReferenceDescription (BO_nbs_desc): Office Chairs; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
